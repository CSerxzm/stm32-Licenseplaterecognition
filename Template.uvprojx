# Keil uVision project Template.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\can;.\APP\tftlcd;.\APP\flash;.\APP\spi;.\APP\stm32_flash;.\APP\sram;.\Malloc;.\APP\sd;.\FATFS;.\FATFS\FATFS_APP;.\FONT;.\APP\ov7670;.\PICTURE;.\Malloc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_flash.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/key/: key.c
    ./APP/ov7670/: ov7670.c sccb.c
    ./APP/exti/: exti.c
    ./APP/time/: time.c
    ./APP/sd/: sd.c
    ./APP/spi/: spi.c
    ./APP/flash/: flash.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group FATFS
    ./FATFS/: diskio.c ff.c
    ./FATFS/FATFS_APP/: fatfs_app.c
    ./FATFS/option/: cc936.c
  group PICTURE
    ./PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group Malloc
    ./Malloc/: malloc.c
